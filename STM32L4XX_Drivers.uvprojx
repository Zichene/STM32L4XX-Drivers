# Keil uVision project STM32L4XX_Drivers.uvprojx, settings and files
target STM32L4S5 (6220000::V6.22::ARMCLANG)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) XRAM(0x20040000,0x00060000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32L4XX_Drivers
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x20040000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ../FirstProject/: gpio.c main.c
  group Headers
    ../FirstProject/: gpio.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.3.2
